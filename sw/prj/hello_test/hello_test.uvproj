# Keil uVision project hello_test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: AMY_PODES_M0O PODES
  cpu: IRAM(0x20000000-0x200007FF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: hello_test +hex
  AfterMake: C:\Keil\ARM\BIN40\fromelf.exe --vhx --32x1 --output=hello_test.txt hello_test.axf
  AfterMake: C:\Keil\ARM\BIN40\fromelf.exe --text -c -s --output=hello_test.lst hello_test.axf
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x800
  group Source Group 1
    ./: startup_AMY.s
    ../../app/: hello_test.c
    ../../core/AMY/: Retarget.c system_AMY.c
    ../../core/uart/: uart.c
